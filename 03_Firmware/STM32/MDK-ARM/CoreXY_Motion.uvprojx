# Keil uVision project CoreXY_Motion.uvprojx, settings and files
target CoreXY_Motion (6240000::V6.24::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CoreXY_Motion +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c misc: -std=gnu99 -fno-common -mfloat-abi=hard -mfpu=fpv4-sp-d16
  c include: ..\Core\Inc;..\App;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\Third_Party\FreeRTOS\include;..\Middlewares\Third_Party\FreeRTOS\portable\GCC\ARM_CM4F
  asm misc: --fpu=FPv4-SP
  asm include: ..\Core\Inc;..\App;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Core\Startup\CoreXY_Motion.sct
  link misc: --diag_suppress=6314,6329,L6312W
  group Application/Core
    ../Core/Src/: main.c stm32f4xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/App
    ../App/: corexy.c interp.c profile.c stepper.c limit.c servo.c comm_uart.c comm_can.c key.c motion.c
  group Drivers/HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c croutine.c stream_buffer.c
    ../Middlewares/Third_Party/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
  group Startup
    ../Core/Startup/: startup_stm32f407xx.s
